Commit message: adding some results

File: environment/urdf/objects/slab2.urdf (robot description, URDF)
Before this commit: robot slab, 1 links, 0 joints
Links:
- removed link slab
- added link slab2, mass 0.1; collision box size=0.02 0.50 0.2; visual box size=0.02 0.50 0.2
