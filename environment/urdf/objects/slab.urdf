Commit message: adding beginning pile scenario

File: environment/urdf/objects/slab.urdf (robot description, URDF)
Before this commit: robot block, 1 links, 0 joints
Links:
- removed link block
- added link slab, mass 0.1; collision box size=0.02 0.3 0.2; visual box size=0.02 0.4 0.2
