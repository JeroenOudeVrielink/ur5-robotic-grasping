Commit message: adding pack scenario

File: objects/test_cube2.urdf (robot description, URDF)
Before this commit: robot block, 1 links, 0 joints
Links:
- link block: geometry collision box size=0.05 0.05 0.05; visual box size=0.05 0.05 0.05
